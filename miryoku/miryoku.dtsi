// Copyright 2022 Manna Harbour
// https://github.com/manna-harbour/miryoku

#include <behaviors.dtsi>
#include <behaviors/mouse_keys.dtsi>
#include <dt-bindings/zmk/keys.h>
#include <dt-bindings/zmk/bt.h>
#include <dt-bindings/zmk/rgb.h>
#include <dt-bindings/zmk/outputs.h>
#include <dt-bindings/zmk/ext_power.h>

#include "miryoku.h"

#include <dt-bindings/zmk/pointing.h>

#define RALT_DEADKEY_MACRO(NAME, BINDING_DEFAULT, BINDING_RALT, BINDING_RALT_CTL) \
    NAME ## _m2: NAME ## _m2 { \
      compatible = "zmk,behavior-mod-morph"; \
      #binding-cells = <0>; \
      bindings = <BINDING_RALT>, <BINDING_RALT_CTL>; \
      mods = <(MOD_LCTL)>; \
    }; \
    NAME: NAME { \
      compatible = "zmk,behavior-mod-morph"; \
      #binding-cells = <0>; \
      bindings = <BINDING_DEFAULT>, <&NAME ## _m2>; \
      mods = <(MOD_RALT)>; \
    };

//exemplo parametros: u_dead_circunflex_kp_a, RA(N6), A
#define DEADKEY_PLUS_LETTER_MACRO(NAME, DEADKEY_KP, LETTER_KP) \
    NAME ## _s2: NAME ## _s2 { \
      compatible = "zmk,behavior-macro"; \
      #binding-cells = <0>; \
      wait-ms = <10>; \
      tap-ms = <10>; \
      bindings = <&kp DEADKEY_KP>, <&kp LS(LETTER_KP)>; \
    }; \
    NAME ## _ns2: NAME ## _ns2 { \
      compatible = "zmk,behavior-macro"; \
      #binding-cells = <0>; \
      wait-ms = <10>; \
      tap-ms = <10>; \
      bindings = <&kp DEADKEY_KP>, <&kp LETTER_KP>; \
    }; \
    NAME ## _s: NAME ## _s { \
      compatible = "zmk,behavior-mod-morph"; \
      #binding-cells = <0>; \
      bindings = <&NAME ## _s2>, <&NAME ## _s2>; \
      mods = <(MOD_LSFT|MOD_RSFT|MOD_RALT|MOD_LCTL)>; \
    }; \
    NAME ## _ns: NAME ## _ns { \
      compatible = "zmk,behavior-mod-morph"; \
      #binding-cells = <0>; \
      bindings = <&NAME ## _ns2>, <&NAME ## _ns2>; \
      mods = <(MOD_LSFT|MOD_RSFT|MOD_RALT|MOD_LCTL)>; \
    }; \
    NAME: NAME { \
      compatible = "zmk,behavior-mod-morph"; \
      #binding-cells = <0>; \
      bindings = <&NAME ## _ns>, <&NAME ## _s>; \
      mods = <(MOD_LSFT|MOD_RSFT)>; \
    };

#define DEADKEY_PLUS_LETTER_IGNORE_SHIFT_MACRO(NAME, DEADKEY_KP, LETTER_KP) \
    NAME ## _2: NAME ## _2 { \
      compatible = "zmk,behavior-macro"; \
      #binding-cells = <0>; \
      wait-ms = <10>; \
      tap-ms = <10>; \
      bindings = <&kp DEADKEY_KP>, <&kp LETTER_KP>; \
    }; \
    NAME: NAME { \
      compatible = "zmk,behavior-mod-morph"; \
      #binding-cells = <0>; \
      bindings = <&NAME ## _2>, <&NAME ## _2>; \
      mods = <(MOD_RALT|MOD_LCTL)>; \
    };

/ {
  macros {
  };
  behaviors {
    u_td_esc_baselayer: u_td_esc_baselayer {
      compatible = "zmk,behavior-tap-dance";
      #binding-cells = <0>;
      #tapping-term-ms = <U_TAPPING_TERM>;
      bindings = <&kp ESC>, <&to U_BASE>;
    };

    DEADKEY_PLUS_LETTER_MACRO(u_dead_circunflex_kp_a, RA(N6), A)
    DEADKEY_PLUS_LETTER_MACRO(u_dead_circunflex_kp_e, RA(N6), E)
    DEADKEY_PLUS_LETTER_MACRO(u_dead_circunflex_kp_o, RA(N6), O)
    DEADKEY_PLUS_LETTER_IGNORE_SHIFT_MACRO(u_dead_tilde_kp_o, LS(RA(GRAVE)), O)
    DEADKEY_PLUS_LETTER_IGNORE_SHIFT_MACRO(u_dead_tilde_kp_a, LS(RA(GRAVE)), A)
    DEADKEY_PLUS_LETTER_MACRO(u_dead_grave_kp_a, RA(GRAVE), A)

    RALT_DEADKEY_MACRO(u_ralt_a, &u_mt LGUI A, &kp RA(A), &u_dead_circunflex_kp_a)
    RALT_DEADKEY_MACRO(u_ralt_e, &kp E, &kp RA(E), &u_dead_circunflex_kp_e)
    RALT_DEADKEY_MACRO(u_ralt_o, &kp O, &kp RA(O), &u_dead_circunflex_kp_o)
    RALT_DEADKEY_MACRO(u_ralt_p, &kp P, &u_dead_tilde_kp_o, &kp RA(P))
    RALT_DEADKEY_MACRO(u_ralt_q, &kp Q, &u_dead_tilde_kp_a, &u_dead_grave_kp_a)
    RALT_DEADKEY_MACRO(u_ralt_c, &kp C, &kp RA(COMMA), &kp RA(C))
  };

  keymap {
    compatible = "zmk,keymap";
#define MIRYOKU_X(LAYER, STRING) \
    LAYER { \
      display-name = STRING; \
      bindings = < U_MACRO_VA_ARGS(MIRYOKU_LAYERMAPPING_##LAYER, MIRYOKU_LAYER_##LAYER) >; \
    };
MIRYOKU_LAYER_LIST
#undef MIRYOKU_X
  };
};

#include "miryoku_shift_functions.dtsi"

#include "miryoku_double_tap_guard.dtsi"

#include "miryoku_mousekeys.dtsi"

#if defined (MIRYOKU_KLUDGE_THUMBCOMBOS)
  #include "miryoku_kludge_thumbcombos.dtsi"
#endif

#if defined (MIRYOKU_KLUDGE_TOPROWCOMBOS)
  #include "miryoku_kludge_toprowcombos.dtsi"
#endif

#if defined (MIRYOKU_KLUDGE_BOTTOMROWCOMBOS)
  #include "miryoku_kludge_bottomrowcombos.dtsi"
#endif

#if defined (MIRYOKU_KLUDGE_TAPDELAY)
  #include "miryoku_kludge_tapdelay.dtsi"
#else
  #include "miryoku_behaviors.dtsi"
#endif

